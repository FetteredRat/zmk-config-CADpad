## boards/shields/cadpad/Kconfig.shield
```kconfig
# Copyright (c) 2020 Pete Johanson
# SPDX-License-Identifier: MIT

config ZMK_KEYBOARD_cadpad
    def_bool y if $(shields_list_contains,cadpad)
```
